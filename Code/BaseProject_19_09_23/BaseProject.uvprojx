# Keil uVision project BaseProject.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BaseProject
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000, USE_HAL_DRIVER, STM32F407xx, USE_STM32F4_DISCO, ARM_MATH_CM4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./src/: main.c MusicPlayer.c
  group Support
    ./src/: libPDMFilter_CM4_Keil.lib stm32f4xx_it.c UART_driver.c stm32f4_discovery_audio.c stm32f4_discovery.c cs43l22.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:File 1.2.0, File System:CORE 6.12.0, File System:Drive:USB 6.12.0, USB:CORE 6.13.6, USB:Host 6.13.6, USB:Host:MSC 6.13.6, Board Support:LED 2.0.0, CMSIS Driver:USART 2.12, CMSIS Driver:USB Host:Full-speed 2.21, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:I2C 1.7.6, Device:STM32Cube HAL:I2S 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SPI 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
